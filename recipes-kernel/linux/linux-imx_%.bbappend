FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Remove-transitional-from-arch-Kconfig.patch"
