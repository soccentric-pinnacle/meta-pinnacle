# Fix S variable for walnascar: git-fetched sources land in ${UNPACKDIR}/git
S = "${UNPACKDIR}/git"
