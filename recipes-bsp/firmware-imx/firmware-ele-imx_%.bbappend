S = "${WORKDIR}/${BP}-${IMX_SRCREV_ABBREV}"
