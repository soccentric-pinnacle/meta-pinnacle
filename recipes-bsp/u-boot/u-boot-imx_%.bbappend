FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
S = "${WORKDIR}/git"
SRC_URI += "file://boot.cmd"
